# Keil uVision project basic_project.uvprojx, settings and files
target basic_project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BAT32G157GK48FA Cmsemicon
  pack: Cmsemicon.BAT32G157.1.00.4
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: basic_project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\application\rgb;..\application\shell_cmd;..\components\cm_backtrace;..\components\cm_backtrace\fault_handler\keil;..\components\sleep_time;..\components\time;..\components\watchdog;..\Drivers\CMSIS;..\Drivers\Driver\inc;..\Drivers\modules\rgb_led\ws2812b;..\Middlewares\private\list;..\Middlewares\private\priv_os;..\Middlewares\private\utilities;..\registeredstart\init_d;..\registeredstart\miscdevice;..\registeredstart\register;..\startup\basic_project;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\keil\ARM_CM0;..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang;..\Drivers\CMSIS\Device\cmsmicon\Include;..\Drivers\CMSIS\RTOS\Template;..\Drivers\platform\BAT32\gpio_led;..\Drivers\modules\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x200002c0 size 0x8000
  group registerestart_init_d
    ../registeredstart/init_d/: init_d.c
  group app_rgb
    ../application/rgb/: rgb.c
  group app_shell_cmd
    ../application/shell_cmd/: fputc_redirect.c
  group drivers_CMSIS
    ../Drivers/CMSIS/Include/: core_cm0plus.h
  group drivers_device
    ../Drivers/CMSIS/Device/cmsmicon/Source/ARM/: startup_BAT32G157.s
    ../Drivers/CMSIS/Device/cmsmicon/Source/: system_BAT32G157.c
  group drivers_driver
    ../Drivers/Driver/src/: clk.c gpio.c iica.c iica_user.c intp.c sci.c sci_user.c
  group drivers_ws2812b
    ../Drivers/modules/rgb_led/ws2812b/: ws2812b.c
    ../Drivers/modules/led/: led.c
  group middlewares_list
    ../Middlewares/private/list/: priv_list.c
  group middlewares_priv_os
    ../Middlewares/private/priv_os/: priv_os.c
  group middlewares_unit
    ../Middlewares/private/utilities/: unit.c
  group middlewares_freertos
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/keil/ARM_CM0/: port.c
  group registerestart_miscdevice
    ../registeredstart/miscdevice/: miscdevice.c
  group registerestart_register
    ../registeredstart/register/: platform_register.c
  group startup
    ../startup/basic_project/: main.c BAT32G_157_it.c
  group drivers_platform_BAT32_gpio_led
    ../Drivers/platform/BAT32/gpio_led/: gpio_led.c
